# Keil uVision project MainBoard.uvprojx, settings and files
target Main (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F407ZGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.13.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: MainBoard
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F40_41xxx,ARM_MATH_CM4
  c include: ..\Device;..\Driver;..\Library\inc;..\User;..\User\Startup;..\System;..\ETH_Driver\inc;..\Fatfs\inc;..\FatfsAPP;..\USB_Device\Core\inc;..\USB_HOST\Core\inc;..\USB_OTG\inc;..\USB_CONFIG;..\DSP_LIB\Include;..\USB_DEV_CDC\inc
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group User
    ../User/: main.c
  group Driver
    ../Driver/: gpio.c bstring.c delay.c flash.c mi2c.c mspi.c usart1.c usart2.c sdio_sd.c rng.c
  group Device
    ../Device/: sram.c
  group Library
    ../Library/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_cec.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dfsdm.c stm32f4xx_dma.c stm32f4xx_dma2d.c stm32f4xx_dsi.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_flash_ramfunc.c stm32f4xx_fmpi2c.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_lptim.c stm32f4xx_ltdc.c stm32f4xx_pwr.c stm32f4xx_qspi.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sai.c stm32f4xx_sdio.c stm32f4xx_spdifrx.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
  group System
    ../User/Startup/: system_stm32f4xx.c startup_stm32f40_41xxx.s
    ../DSP_LIB/: arm_cortexM4lf_math.lib
  group ETH
    ../ETH_Driver/src/: stm32f4x7_eth.c
  group FatFs
    ../Fatfs/src/: diskio.c ff.c ffsystem.c ffunicode.c
  group FatFsAPP
    ../FatfsAPP/: fatfsapp.c fatfsbase.c
  group USB_Host
    ../USB_HOST/Core/src/: usbh_core.c usbh_hcs.c usbh_ioreq.c usbh_stdreq.c
  group USB_Device
    ../USB_Device/Core/src/: usbd_core.c usbd_ioreq.c usbd_req.c
  group USB_OTG
    ../USB_OTG/src/: usb_core.c usb_dcd.c usb_dcd_int.c usb_hcd.c usb_hcd_int.c
  group USB_DEV_CDC
    ../USB_DEV_CDC/src/: usbd_cdc_core.c usbd_cdc_if.c
  group USB_Config
    ../USB_CONFIG/: usb_app.c usb_bsp.c usbh_usr.c usbd_usr.c usbd_desc.c
